# Keil uVision project Drone-gun.uvprojx, settings and files
target Target_1 (6190000::V6.19::ARMCLANG)
  device: STM32F103RB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00020000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Drone-gun +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c misc: -w
  c include: .\app;.\drivers;.\protocol;.\logic;.\core;.\mavlink;.\mavlink\common;.\mavlink\standard
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group app
    ./app/: main.c main.h
  group drivers
    ./drivers/: rcc.c rcc.h gpio.c gpio.h pwm.c pwm.h timer.c timer.h usart.c usart.h
  group protocol
    ./protocol/: mavlink_tx.c mavlink_tx.h mavlink_rx.c mavlink_rx.h cyclops_tx.c cyclops_tx.h cyclops_rx.c cyclops_rx.h
    ./mavlink/: protocol.h
  group logic
    ./logic/: logic_cyclops.c logic_cyclops.h logic_drone.c logic_drone.h
  group core
    ./core/: message_queue.c message_queue.h
software components: CMSIS:CORE 6.1.1, Device:Startup 1.0.0
