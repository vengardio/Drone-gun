# Keil uVision project Drone-gun.uvprojx, settings and files
target Target_1 (6220000::V6.22::ARMCLANG)
  device: STM32F103RB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00020000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Drone-gun +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: .\mavlink;.\mavlink\common;.\mavlink\standard
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Source Group 1
    ./: rcc.c rcc.h uart.c uart.h pwm.c pwm.h servo.h servo.c drone.h drone.c gpio.h gpio.c timer.h timer.c fsm.h fsm.c main.c heartbeat.h heartbeat.c
    ./mavlink/: protocol.h
software components: CMSIS:CORE 6.1.1, Device:Startup 1.0.0
